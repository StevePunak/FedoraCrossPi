# Enable SQLite SQL driver (system sqlite3)
PACKAGECONFIG:append = " sql-sqlite"
